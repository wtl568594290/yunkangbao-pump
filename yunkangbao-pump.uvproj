# Keil uVision project yunkangbao-pump.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: yunkangbao-pump +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC\STC
  group Source Group 1
    ./: STARTUP.A51 led.c main.c master.c pump.c uart.c adc.c temperature.c delay.c
